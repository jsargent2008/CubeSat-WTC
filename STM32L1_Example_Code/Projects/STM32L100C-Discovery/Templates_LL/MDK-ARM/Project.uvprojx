# Keil uVision project Project.uvprojx, settings and files
target STM32L100C-Discovery (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L100RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L100C-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L100xC,USE_STM32L100C_DISCO,USE_FULL_LL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../Drivers/STM32L1xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers/STM32L1xx_LL_Driver
    ../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_ll_comp.c stm32l1xx_ll_dac.c stm32l1xx_ll_spi.c stm32l1xx_ll_gpio.c stm32l1xx_ll_tim.c stm32l1xx_ll_utils.c stm32l1xx_ll_exti.c stm32l1xx_ll_rcc.c stm32l1xx_ll_opamp.c stm32l1xx_ll_dma.c stm32l1xx_ll_pwr.c stm32l1xx_ll_i2c.c stm32l1xx_ll_rtc.c stm32l1xx_ll_crc.c stm32l1xx_ll_adc.c stm32l1xx_ll_usart.c
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32l1xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32l100xc.s
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
