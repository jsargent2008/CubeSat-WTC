# Keil uVision project Project.uvprojx, settings and files
target STM32L152D_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152ZD STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L152D_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L152xD,USE_HAL_DRIVER,USE_STM32L152D_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L152D_EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/CPU;../../../../../../Drivers/BSP/Components;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/STemWin/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Middlewares/STemWin/Config
    ../Src/: LCDConf_stm32l152d_eval.c GUIConf_stm32l152d_eval.c
  group Drivers/BSP/Components/spfd5408
    ../../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
  group Application/User
    ../Src/: main.c BASIC_HelloWorld.c stm32l1xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L152D_EVAL
    ../../../../../../Drivers/BSP/STM32L152D_EVAL/: stm32l152d_eval.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_sram.c stm32l1xx_hal_cortex.c stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_pwr.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr_ex.c stm32l1xx_ll_fsmc.c stm32l1xx_hal_rcc.c stm32l1xx_hal_gpio.c
  group Application/MDK-ARM
    ./: startup_stm32l152xd.s
  group Drivers/BSP/Components/ili9325
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Middlewares/STemWin/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Drivers/BSP/Components/hx8347d
    ../../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin532_CM3_Keil.lib
  group Drivers/BSP/Components/ili9320
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
software components: CMSIS:CORE 4.3.0
